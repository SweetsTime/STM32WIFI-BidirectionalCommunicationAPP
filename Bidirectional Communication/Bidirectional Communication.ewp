# IAR project Bidirectional Communication.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_HD; _DLIB_FILE_DESCRIPTOR; DEBUG_CLOCK=1; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: $PROJ_DIR$; wifi; gpio; Key\; delay\; usart\; led\; tim\; handle\; ..\common\hal\include; ..\common\lib\CMSIS\CM3\CoreSupport; ..\common\lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\common\lib\STM32F10x_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Bidirectional Communication.hex
  ILINK.IlinkOutputFile: Bidirectional Communication.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STM32F10X_MD; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\common\hal\include; ..\common\lib\CMSIS\CM3\CoreSupport; ..\common\lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\common\lib\STM32F10x_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 2
  ILINK.IlinkOutputFile: InfObstacle.out
  group hal
    delay/: delay.c
    handle/: handle.c
    Key/: key.c
    led/: led.c
    wifi/: LQ12864.C shtxx.c wifi.c
    tim/: tim.c
    usart/: usart.c
  group lib/CMMIS
    ../common/lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../common/lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group lib/CMMIS/startup
    ../common/lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_hd.s
  group lib/STM32F10x_StdPeriph_Driver
    ../common/lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_it.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group USER
    ./: main.c
